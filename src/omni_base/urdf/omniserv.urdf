Commit message: change robot size

File: src/omni_base/urdf/omniserv.urdf (robot description, URDF)
Before this commit: robot omniserv, 20 links, 19 joints
Links:
- link base_link: geometry visual cylinder length=0.15 radius=0.40
